# Keil uVision project test.uvproj, settings and files
target test (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\LIB\inc;..\USER;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\CMSIS\CM3\CoreSupport;..\Hardware\led;..\Hardware\key;..\Hardware\TFT;..\LIB\SYSTEM\delay;..\LIB\SYSTEM\sys;..\Hardware\usart;..\Hardware\Timer
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c stm32f10x_it.c
  group LIB
    ../LIB/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
    ../LIB/SYSTEM/delay/: delay.c
    ../LIB/SYSTEM/sys/: sys.c
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StartUp
    ../StartUp/: startup_stm32f10x_md.s
  group Hardware
    ../Hardware/led/: led.c
    ../Hardware/key/: key.c
    ../Hardware/TFT/: TFT.C
    ../Hardware/usart/: usart.c
    ../Hardware/Timer/: Timer.c
